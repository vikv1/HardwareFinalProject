# Keil uVision project 422-FinalProject.uvprojx, settings and files
target Target_1 (ARM-ADS)
  device: TM4C1290NCPDT Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x040000) IROM(0x00000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: 422-FinalProject
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x40000
  group Source Group 1
    ./: driver.c driver_cpg.c driver_keil.c heap.c heap.s stdlib.s svc.s timer.s
software components: CMSIS:CORE 6.1.0, Device:Startup 1.0.0
